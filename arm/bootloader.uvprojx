# Keil uVision project bootloader.uvprojx, settings and files
target dfu_single_bank_hci (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: bootloader +hex
  c flags: Optim=4 wLevel=2
  c define: NRF51,DEBUG_NRF_USER,BOARD_NRF6310, BOOTLOADER_BANKED BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: ..;..\include;..\..\..\..\..\Include\bootloader_dfu;..\..\..\..\..\Include\bootloader_dfu\hci_transport;..\..\..\..\..\Include;..\..\..\..\..\Include\sd_common;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\s110
  memory RVCT4: ROM 0x3c000 size 0x4000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Startup Code
    ../library/: system_nrf51.c
    ../: arm_startup_nrf51.s
  group Source Code
    ./../: main.c
    ../library/: dfu_dual_bank.c bootloader.c bootloader_util_arm.c bootloader_settings_arm.c
  group Services
    ../library/: ble_dfu.c
  group Libraries
    ../library/: hci_mem_pool.c app_timer.c app_scheduler.c app_gpiote.c crc16.c softdevice_handler.c pstorage.c app_button.c nrf_delay.c
  group BLE Transport
    ../library/: dfu_transport_ble.c ble_conn_params.c ble_advdata.c ble_srv_common.c
target dfu_dual_bank_hci (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: as above
  output: bootloader +hex
  c flags: Optim=4 wLevel=2
  c define: as above
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x3c000 size 0x4000
  memory RVCT9: RAM 0x20002000 size 0x2000
target dfu_dual_bank_ble (s110) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: as above
  output: bootloader +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NRF51,DEBUG_NRF_USER,BOARD_PCA10001, BOOTLOADER_BANKED BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: c:\Keil_v5\ARM\Pack\ARM\CMSIS\4.2.0\CMSIS\Include;..\include;..\include\s130_09;c:\Keil_v5\ARM\Device\Nordic\nrf51822\Include;c:\Keil_v5\ARM\Device\Nordic\nrf51822\Include\sd_common;c:\Keil_v5\ARM\Device\Nordic\nrf51822\Include\app_common;c:\Keil_v5\ARM\Device\Nordic\nrf51822\Include\Include\bootloader_dfu;c:\Keil_v5\ARM\Device\Nordic\nrf51822\Include\Include\bootloader_dfu\ble_transport;c:\Keil_v5\ARM\Device\Nordic\nrf51822\Include\Include\ble;c:\Keil_v5\ARM\Device\Nordic\nrf51822\Include\Include\ble\ble_services
  memory RVCT4: ROM 0x3c000 size 0x4000
  memory RVCT9: RAM 0x20002800 size 0x1800
